inherit gtk-immodules-cache-tegra
