FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"

SRC_URI += "file://0001-Make-eglmesaext-header-optional.patch"
