EDEPENDS_X11_append_tegra = " libxdamage"
PACKAGE_ARCH_tegra = "${TEGRA_PKGARCH}"
