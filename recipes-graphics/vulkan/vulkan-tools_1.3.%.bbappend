PACKAGE_ARCH:tegra = "${TEGRA_PKGARCH}"
PACKAGECONFIG:remove:tegra = "wayland"
