PACKAGE_ARCH_tegra = "${TEGRA_PKGARCH}"
PACKAGECONFIG_remove_tegra = "wayland"
