PACKAGECONFIG:tegra = "egl gles2 x11 glx"
PACKAGE_ARCH:tegra = "${TEGRA_PKGARCH}"
