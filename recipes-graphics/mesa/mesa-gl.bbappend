COMPATIBLE_MACHINE:tegra  = "(-)"
