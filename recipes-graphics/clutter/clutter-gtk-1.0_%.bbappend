DEBIAN_NOAUTONAME_${PN} = "1"
