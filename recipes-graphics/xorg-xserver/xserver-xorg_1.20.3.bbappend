FILESEXTRAPATHS_prepend := "${THISDIR}/xserver-xorg-${PV}:"
SRC_URI += "file://systemd-logind-no-platform-bus.patch"
