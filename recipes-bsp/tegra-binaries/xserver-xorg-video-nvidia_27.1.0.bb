require tegra-binaries-${PV}.inc

DRV_EXTRAS = ""

require xserver-xorg-video-nvidia.inc
