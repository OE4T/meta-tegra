require tegra-binaries-${PV}.inc

DRV_EXTRAS = "usr/lib/arm-linux-gnueabihf/tegra/libglx.so"

require xserver-xorg-video-nvidia.inc
