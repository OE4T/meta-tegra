require tegra-boot-tools.inc

SRC_URI = "https://github.com/OE4T/${BPN}/releases/download/v${PV}/${BP}.tar.gz"
SRC_URI[sha256sum] = "f2a0cfd2268add95f5cce2d621e1d1b6bd0f084b4efae779cf8f203641ffad5e"

