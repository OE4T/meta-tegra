require tegra-boot-tools.inc

SRC_URI = "https://github.com/OE4T/${BPN}/releases/download/v${PV}/${BP}.tar.gz"
SRC_URI[sha256sum] = "26c6c0d0678a70342604ab1f974931289117c0776af14b5e1bc393bbbe157818"

