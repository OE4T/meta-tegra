require gcc-${PV}.inc
require gcc-8-cross-canadian.inc



