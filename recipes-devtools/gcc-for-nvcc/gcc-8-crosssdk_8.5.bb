require gcc-8-cross_${PV}.bb
require gcc-8-crosssdk.inc
