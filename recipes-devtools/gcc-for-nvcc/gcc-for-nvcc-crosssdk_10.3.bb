require gcc-for-nvcc-cross_${PV}.bb
require gcc-for-nvcc-crosssdk.inc
