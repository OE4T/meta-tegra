require gcc-for-nvcc-${PV}.inc
require gcc-for-nvcc-source.inc

EXCLUDE_FROM_WORLD = "1"
