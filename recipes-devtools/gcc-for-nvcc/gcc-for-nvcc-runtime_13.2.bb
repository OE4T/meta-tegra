require gcc-for-nvcc-${PV}.inc
require gcc-for-nvcc-runtime.inc
