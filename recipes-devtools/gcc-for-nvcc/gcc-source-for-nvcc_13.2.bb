require gcc-for-nvcc-${PV}.inc
require gcc-source-for-nvcc.inc

EXCLUDE_FROM_WORLD = "1"
