require gcc-for-nvcc-${PV}.inc
require gcc-for-nvcc-cross.inc

