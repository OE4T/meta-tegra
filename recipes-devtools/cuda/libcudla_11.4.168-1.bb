require cuda-shared-binaries.inc

MAINSUM = "4067c13c95f03822e277be90ad46073a2bc318e8430afe29400acfdf798323dc"
DEVSUM = "683a111189c6544c9fae2ce73bea89562c62120af1916bdb7f8ff09e90c4ba70"

RDEPENDS:${PN} = "tegra-libraries-core tegra-libraries-cuda"
