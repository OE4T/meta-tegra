require cuda-shared-binaries.inc

MAINSUM = "0c49c8ee2198b33e39d15422f0dd2f50671057c26c84c19a5e4876864d9a0b4d"
MAINSUM:x86-64 = "b1b0dc80354c9d074a052bd3ccf2b24ccc1b30fcd983956c9110f70af36c704b"
DEVSUM = "2aab163635732dfeb5c37d8aba1f46d49b3999c684fb7d3cd717c2a49b0137d2"
DEVSUM:x86-64 = "1859cb1c6e1e1b1205376b04c3450724d7aa3170b776df0d7ebd8dec74465ca4"

BBCLASSEXTEND = "native nativesdk"
