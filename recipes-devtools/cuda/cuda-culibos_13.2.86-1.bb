require cuda-shared-binaries.inc

MAINSUM = "82674c54a074374245e17e387195b25bf45e60184a72e0d3ef76c68771655160"
MAINSUM:x86-64 = "570f35f4c53d816a443833d32a48c1eac32f91bf477ddd6bb11db84191bf19e7"
DEVSUM = "2b772b411dd80ca397ba8581235c03e045284a9e0fd978fec2fd0f874026537a"
DEVSUM:x86-64 = "67048e2e8dd1599ca21873a0f42df69b9ecac2ca2175d15a64196f819a6619b4"

BBCLASSEXTEND = "native nativesdk"
