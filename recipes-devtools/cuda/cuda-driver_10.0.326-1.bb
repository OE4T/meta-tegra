REPLACE_STUBS = "0"

ALLOW_EMPTY_cuda-driver = "1"

require cuda-shared-binaries-${PV}.inc

