
require cuda-shared-binaries.inc

MAINSUM = "dcf8d138b1c392c9a138ea3d5ae2ada736f0e672fa54d1173bd20ff14e569e90"
MAINSUM:x86-64 = "35e48225153dc58b8c355cb245fc1ca5fb5ea16ad34686bf72d82e8931a9f41d"
DEVSUM = "e23f4e5263a0a9bb89401716f5b0412e11a76ec7ba819975ce1aa0cb76ee0cc1"
DEVSUM:x86-64 = "b44ae760eeb017953052cb3d9f68befb5836714322c545916adb4714b64b63af"

BBCLASSEXTEND = "native nativesdk"
