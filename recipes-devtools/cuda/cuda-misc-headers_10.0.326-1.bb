require cuda-shared-binaries-${PV}.inc

ALLOW_EMPTY_${PN} = "1"
BBCLASSEXTEND = "native nativesdk"
