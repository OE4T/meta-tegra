CUDA_PKG = "cuda-nvtx"

require cuda-shared-binaries-11.8.inc

MAINSUM = "118603e920808564d6597435fc1c4283826f2489043a7529979424b662f22156"
MAINSUM:x86-64 = "a601f412a86563269fa1f9fcf164806e319af502f2e0584935c085ba7931c2c3"

BBCLASSEXTEND = "native nativesdk"
