CUDA_PKG = "cuda-nvprune"

require cuda-shared-binaries-11.8.inc

MAINSUM = "296f676ba577b7cdae14070bb2459b19efb990f7ec13e96d24a488a9bd31a5b6"
MAINSUM:x86-64 = "d7239b3d94f0daacecc049e33ebc92b7bf8611cf90fcb19e99b7279ee1f712f4"

BBCLASSEXTEND = "native nativesdk"
