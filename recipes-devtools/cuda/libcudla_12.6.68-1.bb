require cuda-shared-binaries.inc

MAINSUM = "bc14ff94b6211e7536b54faa6a7f38bb67a919671869c22d13b2bcae2146887c"
DEVSUM = "1327073641f9ba48603338c271095940ca685997e22eda0583202733ad0800ba"

RDEPENDS:${PN} = "tegra-libraries-core tegra-libraries-cuda"
