require cuda-shared-binaries.inc

MAINSUM = "2429ef2555d67c41a7e79c9e04534b4dffba5da652f906547171046d2b6d8c9c"
DEVSUM = "bab8991d1a27064fe973118ff7c08918678414d4979ebc7bfff54d1dc3b29dbb"

RDEPENDS:${PN} = "tegra-libraries-core tegra-libraries-cuda"
