CUDA_PKG = "libcusolver libcusolver-dev"

require cuda-shared-binaries-11.8.inc

MAINSUM = "9ecf297e81c6907e86f333951102f615782a5494c1b89ea781a14904a80a71b1"
MAINSUM:x86-64 = "935471d4a2b133697c6221285205f8ae8edd4a8a6eb3b60f9587d24b0244c1d0"
DEVSUM = "2a4d010849c1af3487e06a04bb2a64dc70d1e6107acbc5bc20020227d627e7aa"
DEVSUM:x86-64 = "96933fb6d9bde2024ff1c2aa66d80858dbc828da918a975ee8afa827001f2a80"

RDEPENDS:${PN} = "libcublas-11-8"
BBCLASSEXTEND = "native nativesdk"
