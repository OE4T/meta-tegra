CUDA_PKG = "cuda-nvtx"

require cuda-shared-binaries-12.9.inc

MAINSUM = "a6a922aafc3ea41e6c0e43103c9ce351ecaafac478e84b956f02d1655250371c"
MAINSUM:x86-64 = "285457dd2afaa8dffb7f79dfe974ca10bd88f026d7e2e18c34a6449e3d752e6c"

BBCLASSEXTEND = "native nativesdk"
