CUDA_PKG = "${BPN}"
L4T_DEB_GROUP = "cuda-nvcc"

require cuda-shared-binaries.inc

MAINSUM = "f94c9173667d4f6a18f19d5a8c932c4ad0f461720967fb4c5193fa839cba0b3d"
MAINSUM:x86-64 = "89d501683cf088241e43033e8ab41108a032c160f95008dec98779904153ca50"

BBCLASSEXTEND = "native nativesdk"
