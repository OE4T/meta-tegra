CUDA_PKG = "cuda-nvprune"

require cuda-shared-binaries-12.9.inc

MAINSUM = "6c159246ab6baf7fa19fc3bdb17d454a61bf9ea6a27aa0652ab45fd3e44b742b"
MAINSUM:x86-64 = "06a9dea23acaed7deec711149f5d96915d9a8611909922b32346e8799812c1cb"

BBCLASSEXTEND = "native nativesdk"
