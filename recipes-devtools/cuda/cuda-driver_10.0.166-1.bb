REPLACE_STUBS = "0"

require cuda-shared-binaries-${PV}.inc

