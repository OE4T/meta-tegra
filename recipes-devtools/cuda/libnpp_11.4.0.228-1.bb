require cuda-shared-binaries.inc

COMPATIBLE_HOST:x86-64 = "(-)"
MAINSUM = "aae29f14c35e8d5ca236245c10e70642cf75cb410a774b6662e1173dc32087ad"
DEVSUM = "ac08bad2703e2e3653041498919704dda831e5d8a41d47d4a10840bbb06dabb7"

BBCLASSEXTEND = "native nativesdk"
