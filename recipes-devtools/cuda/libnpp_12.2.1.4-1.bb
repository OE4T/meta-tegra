require cuda-shared-binaries.inc

MAINSUM = "6985d46919b4514ddd1b067ce70fb89ea709ba026b5a344acef9743f3cf62167"
MAINSUM:x86-64 = "6c054d39725a6935d52ef66159c428435aa623a079b7dc56a57c4c44e2de2b0d"
DEVSUM = "d6b1b981a5b78b2129d369332be7a1400c0bca67ce47afe3e4de27ee1beb9ef4"
DEVSUM:x86-64 = "be4d586f34e15acac908679267a4a40eae364c61ebe7b40e4021fda7901e9802"

BBCLASSEXTEND = "native nativesdk"
