require cuda-shared-binaries.inc

MAINSUM = "c86078219861dc4830f1d63cb6d70844e98b71287cb9431617325f5aa6783c02"
MAINSUM:x86-64 = "72bd2bd194db442a74920f7f1d89a74119c1da26e26452be442bfce721ed6dff"
DEVSUM = "4f459484bb2586d06da56fccb72544df7ce36b928815e477673ab417b15a9daf"
DEVSUM:x86-64 = "07dc5a29cfb780898e741a2c5f33ca26250c8c5046b46ff710aa6cbe4c3e7f71"

BBCLASSEXTEND = "native nativesdk"
