CUDA_FULL_VERSION = "10.2.300-1"
require cuda-shared-binaries-${CUDA_FULL_VERSION}.inc

MAINSUM = "bd844b7a71adc76694caf5da4818ab03f207e3b7f23340aa2fe86909f799fb92"
MAINSUM:x86-64 = "5e55c460ab7e8c874eaf843c690d1069485fa6912407191ff371e93047bbeeba"
DEVSUM = "898fab6cae719007fdf0c8ebb27825bc7dd03e48314297b2b60639b604fa6bc4"
DEVSUM:x86-64 = "186a8d850de1865ea780fed87a0d03b2d698c820da401416507367f286c4edb7"

BBCLASSEXTEND = "native nativesdk"
