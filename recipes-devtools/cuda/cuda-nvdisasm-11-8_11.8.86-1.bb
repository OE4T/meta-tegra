CUDA_PKG = "cuda-nvdisasm"

require cuda-shared-binaries-11.8.inc

MAINSUM = "34b31beffd5dc376d690e78ace62c80838572e89830c1b0037def8705d221f40"
MAINSUM:x86-64 = "81989cf87650ae3126693309f831fbe4332d415a5dc63c25ebb149eed562af70"

BBCLASSEXTEND = "native nativesdk"
