require cuda-shared-binaries-${PV}.inc

