require cuda-shared-binaries.inc

MAINSUM = "87f2161d58e3766f4d1ac695dae673ad6bad0e0e8a5f9866506dccae6c72219f"
MAINSUM:x86-64 = "1974a8b35f3006bc477a74c86a05a0126fde949fb56d986a224d2f48781a2cd2"
DEVSUM = "79bbf5a42f606b22e3d89a09abb6dffc353d3cd8cc083b8c9fdb71e39a968236"
DEVSUM:x86-64 = "b491bf0737ac1a70a56893262a74873c8bfb1708117c4d4768bb1d5b2c6ed55e"

BBCLASSEXTEND = "native nativesdk"

