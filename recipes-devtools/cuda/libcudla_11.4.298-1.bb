require cuda-shared-binaries.inc

MAINSUM = "2134a55a748364c3239e2003b46bf9b14893c6cd5f25c7c93d8f8beb312adf5c"
DEVSUM = "d8c011a0ad05d01da80a569f718c83f5bb00ac91edfa2e00cc54a9ed06c8184d"

RDEPENDS:${PN} = "tegra-libraries-core tegra-libraries-cuda"
