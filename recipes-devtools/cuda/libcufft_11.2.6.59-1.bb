require cuda-shared-binaries.inc

MAINSUM = "68c95fdae59bde441a6ea9fc7d94eebb064f50e41fc51c4aeb4175cf098705e7"
MAINSUM:x86-64 = "255e0ed3c4a56df16a3745ccc2404936c72d8128b3e9929ad53d49e65d72a58a"
DEVSUM = "e4322f0712961be4b4bba58015e28dde0c30224cad27561cc73d4756463531f4"
DEVSUM:x86-64 = "70208f4fe6f046b0f145202c88b6b0329971ed6221496920082015e5b9a18e0c"

BBCLASSEXTEND = "native nativesdk"
