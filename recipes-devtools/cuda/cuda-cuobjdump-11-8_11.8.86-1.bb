CUDA_PKG = "cuda-cuobjdump"

require cuda-shared-binaries-11.8.inc

MAINSUM = "697f4df8a89c798caa459c213fdead5ccea220cc46805ef3d7651add59a23289"
MAINSUM:x86-64 = "e7c8fbfd2d0f515ddf9b98aac9ac43da9c126ee3d0ab9f14789e86f4cd654655"
BBCLASSEXTEND = "native nativesdk"
