require cuda-shared-binaries.inc

COMPATIBLE_HOST:x86-64 = "(-)"
MAINSUM = "471be4b1f4d3c53eeed9e5ee7b6303b64f551475b3d6ae2fdbfbcf51481b721e"
DEVSUM = "b22b3acc7a8432186934c61d0008bc66c8e2e5995b1117a250ae4598f1b70afd"

BBCLASSEXTEND = "native nativesdk"

