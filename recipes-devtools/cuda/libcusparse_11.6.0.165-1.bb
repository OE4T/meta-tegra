require cuda-shared-binaries.inc

MAINSUM = "1c5b2fb338d0fa233b10f21c144f2f8543da3aa3ae05fccd06fa31ee060962de"
MAINSUM:x86-64 = "92902e10fe8a4ddbbeacda66282f8ab39e29a4c42d557b1dc3eaffec6a055a0b"
DEVSUM = "8002bc063bdee1d278d5361d81abda7b75f627e3c5e8ed650051390281376fc6"
DEVSUM:x86-64 = "0a8d48bae061d5dfae1cddc9c754bce6798b36dac22fd6706909e6cd7b4bd153"

BBCLASSEXTEND = "native nativesdk"
