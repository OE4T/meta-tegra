CUDA_FULL_VERSION = "10.2.300-1"
require cuda-shared-binaries-${CUDA_FULL_VERSION}.inc

MAINSUM = "31a32e7c7e439bc34331d32b93392d08de6c9893d5083865b93703509d6fb7d6"
MAINSUM:x86-64 = "e408e5fb1bcf3a874e816fe4b9af39baf36cb5bdd031fafcb22f41c9ef542942"
DEVSUM = "c86b549b4501a8ddd451dd7f46ea55b79d548bd987aaa17f3af03813e4b90dba"
DEVSUM:x86-64 = "b0f260ebf1105bd80273a2f88d954866be1f8c6db9b1eddb11b76f01ac274bb8"

BBCLASSEXTEND = "native nativesdk"
