require cuda-shared-binaries.inc

MAINSUM = "0658635943cb77024c03990a9df0fd2543e4352377dff7b5a8654a87c4a54387"
MAINSUM:x86-64 = "27d51c1e0bf23dae9df62c8ff9efb77b4f8c82a30cc662ebac6757071ca7c617"
DEVSUM = "6414bacf8dcd7da1256a5251c32d1fa22d56c378dabc337d1a56d90eba631502"
DEVSUM:x86-64 = "74f959bacb26f4a5ca2065c424bac7ddc8b104e22a7b31ecf8074ba6fb016486"

BBCLASSEXTEND = "native nativesdk"
