require cuda-shared-binaries.inc

MAINSUM = "b1fedfac989075df9dfa3c36977df61fd3f3f1969bef10c451d03b3801dda04a"
MAINSUM:x86-64 = "3746dee4ea5323608ccff2efe66ad6d0e45500a906a31bd312f7bf217676f362"
DEVSUM = "115a00856b786de1fe533ad537598327de08d9a98358f3c01461db9c2eca5725"
DEVSUM:x86-64 = "98871901662345d4edc4e99a97591bf1542c3420da8befb37463a1fdcb300add"

BBCLASSEXTEND = "native nativesdk"
