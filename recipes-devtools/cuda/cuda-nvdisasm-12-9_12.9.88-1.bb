CUDA_PKG = "cuda-nvdisasm"

require cuda-shared-binaries-12.9.inc

MAINSUM = "57f05c7d28eb69add070dcb5a7ba5183f26d25dbd38cfc89853e49c87d44cc96"
MAINSUM:x86-64 = "e2d186f399f4d8c2740b59bffde397b8a1bb5d344cfdf91355e7af10e3a9f3db"

BBCLASSEXTEND = "native nativesdk"
