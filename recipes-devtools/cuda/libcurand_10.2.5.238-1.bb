require cuda-shared-binaries.inc

COMPATIBLE_HOST:x86-64 = "(-)"
MAINSUM = "34f44a172ec78beb05b2ac21207f1f5d485841f88f6a6b4de6ca71b64531bf37"
DEVSUM = "b9e8e720d55fe896414838b98cdec4937139b1794f501a4abc976d13a61882aa"

BBCLASSEXTEND = "native nativesdk"
