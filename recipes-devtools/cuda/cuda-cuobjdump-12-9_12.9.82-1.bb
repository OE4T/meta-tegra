CUDA_PKG = "cuda-cuobjdump"

require cuda-shared-binaries-12.9.inc

MAINSUM = "d2aae7c146c1a64a08df802c2328f2aaa7d68744f2a5b4344c5c1a8f0924b0e8"
MAINSUM:x86-64 = "c2442f96785b9d06818e4d4edc1a2612227da14450c2ac704db7c97239116782"
BBCLASSEXTEND = "native nativesdk"
