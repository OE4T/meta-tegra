DEPENDS = "cuda-driver cuda-misc-headers"

require cuda-shared-binaries-${PV}.inc

