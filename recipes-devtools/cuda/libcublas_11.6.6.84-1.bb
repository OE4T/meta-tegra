require cuda-shared-binaries.inc

MAINSUM = "53de2203b45dc2e47472c9a48e2dd6c5d11b78a9ee94a1d8e5707e11feffe703"
MAINSUM:x86-64 = "3ce18487d37e3fa518c3ff7940e4eac95e41ec79dd8d8b4520fc16f635958bac"
DEVSUM = "8db159ef73ccaa926f327d324704dcea157d734e0a70c3df0e12d6367ca2d48a"
DEVSUM:x86-64 = "4bb7c0ddee53456323aa34f2baec383ddc3c3cc125ba6c67b0faecde4802b44a"

BBCLASSEXTEND = "native nativesdk"
