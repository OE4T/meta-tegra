require cuda-shared-binaries.inc

MAINSUM = "98a261e83c0c8c9ff546e1d41b17101bfa7dd50968985bcabad48f6f1aaaf917"
MAINSUM:x86-64 = "7ccb61c2132cd5d3117437f594ad25eadb3a96f0f1513abd3ae8885f4837e4e2"
DEVSUM = "2ad235cbddc3079fc8079919dc31fdb5e4f3388634b2f36cd61f6e29bfcdfd6e"
DEVSUM:x86-64 = "1a7f2acc4abbb73529ecfbab193f033d0a13403f056ecba58b650ec739791ac7"

BBCLASSEXTEND = "native nativesdk"
