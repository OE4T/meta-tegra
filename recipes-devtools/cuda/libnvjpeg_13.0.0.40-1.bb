CUDA_INSTALL_ARCH:class-target = "sbsa"
CUDA_INSTALL_ARCH:class-native = "${HOST_ARCH}"

require cuda-shared-binaries.inc

MAINSUM = "9593cf07998c99c0ba427caa1ab9e81362c9b177b8c86b199b587d1c54be11a7"
MAINSUM:x86-64 = "31f211245de42397b8cb017c82af27395962d37ee0c3c1fbf92e673aca47039c"
DEVSUM = "83cbae36bee26be15919091cde0c6141d16b2401c9b6df48f9c648c52ed20da8"
DEVSUM:x86-64 = "64696062f73611b73be75a3e1fc442ea17017531e1e7ad925e6b3cd85903043e"

BBCLASSEXTEND = "native nativesdk"
