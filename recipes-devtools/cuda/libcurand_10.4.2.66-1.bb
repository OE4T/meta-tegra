
require cuda-shared-binaries.inc

MAINSUM = "2539fc1c722428346fce9320be2aa35beb0f7c8b546f92c3f9365d2123b218dc"
MAINSUM:x86-64 = "fd83cd2f5816c7e412120a00ca38a5db3a48dd784219207d433a06698d1dbdd7"
DEVSUM = "2a248f0dd81dc3e88c8b39186e0b013f2cf6827694c750c20c8322f8e92b82e2"
DEVSUM:x86-64 = "494a4293af66768139b3501bd7e4e96e39520ba20b93b7b583024e27ca0551d8"

BBCLASSEXTEND = "native nativesdk"
