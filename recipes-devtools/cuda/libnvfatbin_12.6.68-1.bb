require cuda-shared-binaries.inc

MAINSUM = "2dd434eafdb320bcc59465abb1eafa951fdd57ddd00afc4b1b5f1e2082d12330"
MAINSUM:x86-64 = "5cae4ae3bb05b3cb4d15962f02a35853ca27e561e321691a70445161e7a83290"
DEVSUM = "925e2735799bfdcd3c36e2b4005d013fd0bffe4113d7f3142f1a624a5c31d8e1"
DEVSUM:x86-64 = "df149d07a56ffd109218628d2de1fc856ba61c0b1384428a1ccc2f4cb3371926"

BBCLASSEXTEND = "native nativesdk"
