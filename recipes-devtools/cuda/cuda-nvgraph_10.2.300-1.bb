DEPENDS = "libcurand libcusolver"

require cuda-shared-binaries-${PV}.inc

MAINSUM = "88412a2eecdc5dc2f3db7f6f2dea3d13c234114b8f36ec0356d237190504748e"
MAINSUM:x86-64 = "c6fdfffc7a8181382c00d7083d5fb29808287b8edc0602c64285d96373e326bb"
DEVSUM = "f280b981d54745d24bd933c48eba76903f4174d13e38aae89454f29433355186"
DEVSUM:x86-64 = "a0967de74d4a0685f9b0f2c010eff6906ad7618d09e92f11b5bcd1ceb76a3dd5"

BBCLASSEXTEND = "native nativesdk"
