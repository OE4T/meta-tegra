require cuda-shared-binaries.inc

MAINSUM = "7b8e1c2ce01db9539e92439859b3fb72ca95ff9da4424c9b8cd711934e7c7265"
MAINSUM:x86-64 = "93eb99440cc9298dda9831f66f78bce05b34714dd9b1810f01d901470be30adc"
DEVSUM = "cee52e65f17de85e798130a7a201e3eb8cc127586f636aac6f145db91a00fb9d"
DEVSUM:x86-64 = "85198f48b48555b80cfdf960c631615867b5217afb73536fd46b8e20805f14d2"

BBCLASSEXTEND = "native nativesdk"
