CUDA_PKG = "cuda-cuxxfilt"

require cuda-shared-binaries-12.9.inc

MAINSUM = "0e869291ac1055cd53304d60a065b95610f6b6aeebc34417738a20124e1f3f62"
MAINSUM:x86-64 = "d3431fdaa151eaa8bdebb96f847f878355dbf314ae15ea0c53a09d46a7682558"

BBCLASSEXTEND = "native nativesdk"
