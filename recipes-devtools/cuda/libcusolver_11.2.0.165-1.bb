require cuda-shared-binaries.inc

MAINSUM = "e2ad1d7a540b49f9038842848a68a21a08050f1e01f4b5a4ae6d9a9a8df86d60"
MAINSUM:x86-64 = "130eef5afe5cf576c01a48efa5b707f749ddf0ebe0072317541caa79dc19d780"
DEVSUM = "3dd581ab08ed16b8f6e59a506033fb08e1659e0bd0d5449b1a9d016b433d86dc"
DEVSUM:x86-64 = "86a7a8fc39a63880d03649cd548b62c29b498b441b1346571d22d63002b2fde6"

RDEPENDS:${PN} = "libcublas"
BBCLASSEXTEND = "native nativesdk"
