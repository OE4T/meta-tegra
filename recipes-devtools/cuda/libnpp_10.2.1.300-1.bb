CUDA_FULL_VERSION = "10.2.300-1"
require cuda-shared-binaries-${CUDA_FULL_VERSION}.inc

MAINSUM = "dc51dc218b7652680138ca236877d01ff0b65546d60a113276ded05f1fea967e"
MAINSUM:x86-64 = "481f139d8e8c340bc0207e4623ee88e0b4d9b3aa5fc04dcb97f8765b87b87af5"
DEVSUM = "4c64992156eaeb982af504a41920a33df01c701286903d07fe23c1d20c902b38"
DEVSUM:x86-64 = "4f50d700dc16b8c9e012e88237fdd22f99238ae86888eb373c15d81223765f89"

BBCLASSEXTEND = "native nativesdk"
