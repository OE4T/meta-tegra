require cuda-shared-binaries.inc

MAINSUM = "65284b80a1fdbfe7fe3ee4e53720a71e4496df37b4702b5a2559f4bc15614b0f"
MAINSUM:x86-64 = "70dd08b3896662f4236aaa49aecb4873b7c99a7a8000cbf62f4c82655b0b17d5"
DEVSUM = "7ca13092a34005bda3b82a8e61a156dee2b0c04c729d265501a1d2827783a258"
DEVSUM:x86-64 = "bc26d576ff52997d46d0f71fd29959bf5951521cf9e0535d3c79abe137634af6"

BBCLASSEXTEND = "native nativesdk"
