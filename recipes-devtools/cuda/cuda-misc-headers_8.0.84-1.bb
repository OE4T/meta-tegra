require cuda-shared-binaries-${PV}.inc

RDEPENDS_${PN} = ""
