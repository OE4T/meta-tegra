require cuda-shared-binaries.inc

MAINSUM = "073fcfce40b5933fa4ff97d133a1f9e230f5dc46a348b474064cdc459033e76b"
MAINSUM:x86-64 = "e33cdf0f07cd2a61fec4ec44a258e5eb0d959e633a3ec10f975628383e746d2a"
DEVSUM = "c3d9cb979ab61b570d33ec75e1d537acd826b30ca75789e98f65bb9a4e3ae88c"
DEVSUM:x86-64 = "a2014054c7ce37632b7614df08f80fa2a92e908b79676555edf64309fdf21fe4"

BBCLASSEXTEND = "native nativesdk"
