require cuda-shared-binaries.inc

MAINSUM = "0f9aef0b462c6f583a194dea74b5811ff4e07d7999832c619f2fea3a3339b1cc"
DEVSUM = "be74d8ad62d741320e017da71f0f1e1ee6ad47d3f9c5e4dbae23260d42831173"

RDEPENDS:${PN} = "tegra-libraries-core tegra-libraries-cuda"
