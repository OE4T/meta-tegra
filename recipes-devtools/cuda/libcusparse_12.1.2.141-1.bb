require cuda-shared-binaries.inc

MAINSUM = "f167c5da94086abdecbb5ae96ce91ca708e9212896afe50456bc85b7a3dc38d0"
MAINSUM:x86-64 = "f1419182f07c047a223f3e79ef2a4febc7117044020568ccd6531028033081c3"
DEVSUM = "60ae081519d8d28ca7f69623929bc88dda5d4ed1f3e5d356e4c08436ccc09393"
DEVSUM:x86-64 = "0bc5447c0a6a48aae5457fc82ffd57a7ec0c9665d68617c0593feed4941955a5"

RDEPENDS:${PN} = "libnvjitlink"
RDEPENDS:${PN}-stubs = "libnvjitlink"
BBCLASSEXTEND = "native nativesdk"
