require cuda-shared-binaries.inc

MAINSUM = "d4e0025162c0c68d792b373f50843328234918e450258873f6325630580af692"
MAINSUM:x86-64 = "e8c7492ca315fe3ea4914d015a3661fd89d568896001159c2f983a97153003b0"
DEVSUM = "345c8da638cd8e86f8a1d14f23efc125cfd71a287d5d275d3f6093be1172647f"
DEVSUM:x86-64 = "1100bbd9f49d88083f28a93c40454f3f81f2ad5061d4d8bf62dd92c8b292bb92"

BBCLASSEXTEND = "native nativesdk"
