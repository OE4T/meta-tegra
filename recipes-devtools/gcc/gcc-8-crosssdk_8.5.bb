require gcc-8-cross_${PV}.bb
require gcc-crosssdk.inc
