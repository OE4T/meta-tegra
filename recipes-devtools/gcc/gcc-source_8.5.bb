require gcc-${PV}.inc
require gcc-8-source.inc

EXCLUDE_FROM_WORLD = "1"
