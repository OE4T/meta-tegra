require gcc-${PV}.inc
require gcc-8-cross.inc

