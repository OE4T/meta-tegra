EXTRA_OECONF_append_arm = " --with-default-libstdcxx-abi=gcc4-compatible"
