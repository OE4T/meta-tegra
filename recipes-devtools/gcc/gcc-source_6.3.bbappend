FILESEXTRAPATHS_prepend := "${THISDIR}/gcc-6.3:"
SRC_URI += "file://backport-use-ucontext-t-not-struct-ucontext.patch"
