RDEPENDS:packagegroup-base-bluetooth:append:tegra = " tegra-bluetooth"
RDEPENDS:packagegroup-base-wifi:append:tegra = " tegra-wifi"
