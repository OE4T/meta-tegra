RDEPENDS:${PN}:append:tegra = " gcc-for-nvcc-cross-canadian-${TRANSLATED_TARGET_ARCH}"
