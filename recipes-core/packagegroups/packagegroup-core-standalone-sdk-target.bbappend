RDEPENDS:${PN}:append:tegra = " libgcc-for-nvcc-dev gcc-for-nvcc-runtime-dev"
PACKAGE_ARCH:tegra = "${TEGRA_PKGARCH}"
