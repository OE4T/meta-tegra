FILESEXTRAPATHS_prepend := "${THISDIR}/udev:"

SRC_URI += " \
    file://restore-firmware-builtin.patch \
"
