require linux-yocto-tegra.inc
