TEGRA_LINUX_VERSION_EXTENSION = "-rt"

require linux-noble-nvidia-tegra.inc

SRC_URI += "file://enable-preempt-rt.cfg"
