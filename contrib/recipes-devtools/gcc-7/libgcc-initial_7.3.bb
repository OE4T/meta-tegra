require gcc-${PV}.inc
require libgcc-initial.inc
