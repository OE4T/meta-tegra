require gcc-${PV}.inc
require libgfortran.inc

