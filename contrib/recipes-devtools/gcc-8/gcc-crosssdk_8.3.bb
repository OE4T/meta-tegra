require gcc-cross_${PV}.bb
require gcc-crosssdk.inc
