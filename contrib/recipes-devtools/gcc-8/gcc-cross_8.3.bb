require gcc-${PV}.inc
require gcc-cross.inc

