L4T_VERSION ?= "36.5.2"
