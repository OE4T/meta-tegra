SRC_URI = "git://gitlab.com/libeigen/eigen.git;protocol=https;nobranch=1"
SRCREV = "21ae2afd4edaa1b69782c67a54182d34efe43f9c"
S = "${WORKDIR}/git"
