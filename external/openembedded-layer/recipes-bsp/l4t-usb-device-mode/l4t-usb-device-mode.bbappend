# meta-oe provides libusbgx, prefer that
L4T_USBGX_DEPENDS = "libusbgx"
