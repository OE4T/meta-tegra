
DEPENDS += "virtual/libgbm"

