require gstreamer1.0-plugins-nvcompositor.inc
