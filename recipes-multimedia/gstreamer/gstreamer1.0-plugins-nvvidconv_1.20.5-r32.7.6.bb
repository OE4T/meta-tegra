require gstreamer1.0-plugins-nvvidconv.inc

SRC_URI += "file://0003-Update-allocator-to-use-actual-frame-sizes.patch"
