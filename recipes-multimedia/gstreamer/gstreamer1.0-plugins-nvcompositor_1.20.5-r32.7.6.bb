require gstreamer1.0-plugins-nvcompositor.inc

SRC_URI += " file://0001-Update-for-gstreamer-1.18.patch"
