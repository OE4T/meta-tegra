PACKAGECONFIG:append:tegra = " v4l2"
PACKAGE_ARCH:tegra = "${TEGRA_PKGARCH}"
